# Repository matgyver/temperature-pendant

File README.md:

/*
 * BlinkM Necklace with temperature sensor and switch
 * This will read in a temperature sensor and set the color
 * of the RGB LED accordingly.  A switch is used to rotate between
 * Temp mode, color mode and simulated off (LED is off, proc still running)
 * 
 * 2013 Matthew E. Nelson - Aerodyne Labs
 * www.rfgeeks.com          www.aerodynelabs.com
 */

/* Notes on this project - Please Read This if you are having problems!

Known Issues

*  There is some delay with the switch and switching modes, this is due to the software PWM, see note below

---------------------------------------------------------------------------------------------------------------

This project uses a BlinkM or MiniM module to read a temp sensor (analog) and use that to control the RGB LED on the module
The BlinkM/MiniM modules have an ATTiny85 (MiniM) or ATTiny44 (BlinkM).  While these processors do have PWM, the pins on the RGB
are not tied to the hardware PWM outputs except for Blue.  Therefore, a software based PWM was needed.  The software PWM that I am
using (see note below on original Author) does a pretty good job, but does have some limitiations.  This is mainly due to the fact 
that the ATTiny processors only have 1 timer.  The values that I choose was picked to produce as smooth of a result I could get while 
keeping the functionaility consistent.

Programming this requires a programmer as the BlinkM or MiniM do not have an arduino comptabible bootloader (or a HW serial port for that matter).  
For this reason you will need an ISP.  Fortunatly you can use an Arduino as an ISP.  Instructions for programming the BlinkM and MiniM can be 
found on ThingM's blog:  http://blog.thingm.com/2011/03/blinkm-smart-led-as-the-smallest-arduino/.  It's a little dated but still applies.

In addition, you will need to add the ATTiny44 and 85 processors to the Arduino IDE.  You can information about this on MIT's website located
here:  http://hlt.media.mit.edu/?p=1695.  There is a known issue with the Arduino IDE being able to address the full 8KB on the processor.  To fix
this issue, see this:  https://github.com/TCWORLD/ATTinyCore/tree/master/PCREL%20Patch%20for%20GCC.  Basically there is a problem with the version
of the compilier that Arduino uses, so this patch will fix that bug that limits it from compiling for programs larger than 4KB.  

UPDATE!
Through this process I ended up switching cores.  This was mainly due to the addition of using an ISR.  You can find the core I used here https://code.google.com/p/arduino-tiny/

Another note on the ISR.  The ISR does indeed work, however since the softwarePWM also uses that timer, it has to finish that before it goes to the ISR.  The result is that if
you push the button and it is pulsing a color, it will not move to the next mode until the the fade is complete.  Remember, it's a "feature".

The Software PWM routine was original written by Ernst Christensen and was found in the following Arduino forum thread: 
http://arduino.cc/forum/index.php/topic,75334.0.html

All credit goes to him for the handy routine

## KiCad design Hardware/temperature_pendant.kicad_pcb

File Hardware/readme.txt:

A place for hardware files including schematic and boards

Parts:
BT1: BATTERY
C1, C3: .1 uF
C2: 4.7uF
D1: LED
J1: CONN-6
J2: USB_MINI
R1: 330
R2: 2K
R3: 10k
SW1: SW-MOM
U1: MCP73831/2
U2: BLINKM/MINM
U3: TMP3X

Connections:
+BATT: BT1.1 (+), C1.1, C3.2, J1.3, SW1.2, U1.3 (V_BAT), U2.3 (Vdd), U3.1 (Vs)
GND: BT1.2 (-), C1.2, C2.2, C3.1, J1.2, J2.5, R2.2, R3.2, U1.2 (Vss), U2.2 (GND), U3.3 (GND)
MISO: J1.6, U2.6 (MISO)
unnamed: R2.1, U1.5 (PROG)
unnamed: D1.1 (A), R1.1
unnamed: D1.2 (K), U1.1 (STAT)
unnamed: C2.1, J2.1, R1.2, U1.4 (V_DD)
RST: J1.1, U2.1 (RST)
SW: J1.4, R3.1, SW1.1, U2.4 (SDA/PWM)
TEMP: J1.5, U2.5 (SCL/AIN), U3.2 (Vout)

Board: 2 copper layers, 14 parts (0 on the bottom side), 10 nets, no tracks yet.

## Commit log

2013-10-15 Update README.md
    Updated information on project
2013-10-15 Inital code commit
    Mostly working code, still a WIP
2013-10-15 folder setup
2013-10-21 Initial commit on hardware
    Start on schematic
2013-10-22 Added additional components
    Added BlinkM andprogramming header to schematic.
2013-10-26 Updates
    Completed schematic. Minor revisions, added comments to Arduino code.
    Fixed Library reference issue.
2013-10-26 PCB added
    First cut of the PCB layout
2013-10-27 Updated board
    Updated board and first revision routing
2013-10-28 Added Gerber files
    Added Gerber and 3D file
2013-10-28 Minor changes
    Minor revisions to code
2013-11-05 Updated board files for MinM
    Updated boards and gerber files for the MinM module instead of the
    BlinkM module. This does result in a smaller size board, slightly.
    Otherwise the schematic is the same.
2013-11-05 Minor commit
    Minor change
2013-11-05 Fixed Gerber issue
    Fixed an issue with the Gerber files
2013-11-05 Fixed Gerber issue
    Fixed Gerber issue
2013-11-06 Added drill hole
    Added a mechanical hole that could be used for chain for the pendant.
2013-11-17 Updates
    Minor updates based on testing with the actual board.
2013-11-17 Fixed sensor, added locking connector
    Fixed the backward wiring on the sensor, added locking connector. Fixes
    issue #4 for the sensor and issue #3 for the locking connector.
2013-11-17 Minor change cleanup
    Moved switch and battery connector. Cleaned up tracks in preparation
    for a redo on the layout.
2013-11-17 Final cleanup and new routed board
    Re-routed board based on new placement
2013-11-18 Updated
    Fixed same issues as in the bigger BlinkM version. Re-did placement on
    switch and battery connector. Re-routed.
2013-11-18 Added BOM
    Added BOM
2013-11-18 Added 3D
    3D model of the board in STL format
2013-12-02 Added ISR routine
    Added a ISR to better handle the button presses to switch modes.
    Cleaned up other aspects of the code. Still have some debugging to
    do...
2013-12-03 Added debounce
    Added debounce routine to ISR to better handle switch. HW change will
    also help address some issues in the next HW Rev. Cleaned up some code,
    tweaked temperature mapping values. Added some other "flashy" modes.
2013-12-07 Enabled built-in pull ups
    Enabled built-in pull down resistor to better stabilize the SW input.
    Testing if I still need an external pull-down but for now added one in
    the schematic.
2013-12-08 Fixed issues
    Fixed several issues. In the schematic added pull-down resistor and
    also some caps to improve performance and noise issues. Re-wrote the
    temperature reading routine and color picking. Enabled the internal
    voltage reference and set to 2.56 VDC reference voltage. This means the
    values won't change as the battery voltage drops over time. Cleaned up
    various parts of the code. Tested to work so far on the rev1 boards.
2013-12-08 Update README.md
    Added information about switching ATTiny Core and ISR
2013-12-09 Clean up, change to function
    Cleaned up the code some more, removed extra variables, comments and
    re-organized. Changed the RGB rotation to change the speed of the
    rotation based on the temperature, the hotter it is, the faster it will
    go.
2013-12-09 Updated PCB
    Updated PCB with changes done to schematic. made the board longer but
    not as wide.
2013-12-09 Minor update
2014-01-11 Added MCP73831 Charger
    Deceided to design around using a 3.7 Li-Poly flat pack battery. To
    make it more user friendly (ie don't need to fumble getting the battery
    out) I have added a MCP73831 Charger. Currently set to 500 mA charge.
    This should be fine for any Li-Poly battery that has a maximum voltage
    of 4.2 and a minimum capacity of 500 mAh. Batteries with smaller
    capacity may be damaged by the higher charge current as most batteries
2014-01-11 updated PCB
    Updated PCB layout with new charger and a few other changes to packages.
    Swapped out JST connector for the smaller PH series.
2014-01-11 Switched to MinM
    Switched to MinM board in Master branch
